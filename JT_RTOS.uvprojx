# Keil uVision project JT_RTOS.uvprojx, settings and files
target freeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: freeRTOS_v1 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\APP;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM3;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\Driver\LED;.\Driver\KEY;.\Driver\Timer;.\Driver\DS18B20
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STM32Periph
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dbgmcu.c misc.c stm32f10x_tim.c
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s system_stm32f10x.c core_cm3.c
  group FreeRTOS_CORE
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group SYSTEM
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/delay/: delay.c
  group APP
    ./APP/: main.c APPTaskDef.c APPTaskDef.h DS18B20Task.c DS18B20Task.h LEDTask.c
  group Driver
    ./SYSTEM/usart/: usart.c
    ./Driver/LED/: led.c led.h
    ./Driver/KEY/: key.c key.h
    ./Driver/Timer/: timer.c timer.h
    ./Driver/DS18B20/: DS18B20.c DS18B20.h
